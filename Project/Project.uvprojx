# Keil uVision project Project.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SYS_SUPPORT_OS,HSE_VALUE=12000000
  c include: ..\Libraries\RCC;..\User;..\Libraries\USART1;..\App\App_USART1_Recv;..\Libraries\TIM3;..\Hardware\DS1302;..\Libraries\SPI2;..\Hardware\W25Q64;..\Driver\TLSF;..\Driver\Link_List;..\Driver\Circular_Queue;..\Driver\CRC16;..\Libraries\Flash;..\Libraries\IWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c systick.c
  group Libraries
    ../Libraries/RCC/: RCC_CLK_Config.c
    ../Libraries/USART1/: USART1.c
    ../Libraries/TIM3/: TIM3.c
    ../Libraries/SPI2/: SPI2.c
    ../Libraries/Flash/: Flash.c
    ../Libraries/IWDG/: IWDG.c IWDG.h
  group Hardware
    ../Hardware/DS1302/: DS1302.c
    ../Hardware/W25Q64/: W25Q64.c
  group App
    ../App/App_USART1_Recv/: App_USART1_Recv.c
  group Driver
    ../Driver/TLSF/: TLSF.c
    ../Driver/Link_List/: Link_List.c
    ../Driver/Circular_Queue/: Circular_Queue.c
    ../Driver/CRC16/: CRC16.c
software components: CMSIS:CORE 5.3.0, RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Coroutines 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Message Buffer 10.5.1, RTOS:Stream Buffer 10.5.1, RTOS:Timers 10.5.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.6.0, Device:StdPeriph Drivers:DBGMCU 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:FSMC 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:IWDG 3.6.0, Device:StdPeriph Drivers:PWR 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:RTC 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
